# Repository JasonClock/CNC_Buck

## KiCad design circuit/数控电源 - 副本/数控buck.kicad_pcb

Parts:
C1, C6, C37: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 2.2n; C_0603_1608Metric
C4: 3.3n; C_0603_1608Metric
C5, C11: 56p; C_0603_1608Metric
C7, C38: 10u; C_1210_3225Metric
C8: 10u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C9: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C26: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 470u; CP_Elec_10x10.5
C14, C16: 12p; C_0603_1608Metric
C15, C18, C19, C27, C40: 100u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22, C29, C33, C34, C35, C43: 100n; C_0603_1608Metric
C25: 2.2u; C_0603_1608Metric
C28, C30: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31: C_Polarized_US_68u; CP_EIA-7343-31_Kemet-D
C32, C36: 100nf; C_0603_1608Metric
D1, D6: SMCJ58A; D_SOD-123F
D2: SS26; D_SMA
D3, D4: B5819WS; D_SOD-323
D5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13: SS24; D_SMA
J1: Conn_01x06_MountingPin; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J2: Conn_01x02; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J5: Conn_01x02; AMASS_XT30U-F_1x02_P5.0mm_Vertical
L1: 68u; L_Bourns_SRP7028A_7.3x6.6mm
L2: 33u; L_APV_APH1770
L3: 68u; L_7.3x7.3_H3.5
Q1, Q2: BSC070N10NS3G; TDSON-8-1
R1: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R7, R8, R10, R15: 11k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R12, R13, R14: 1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 11k; R_0603_1608Metric
R11: 5m; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R16, R19: 27k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R20: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: STM32F334R8Tx; LQFP-64_10x10mm_P0.5mm
U2: LM5164DDA; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias
U3, U6: TLV9062; SOIC-8_3.9x4.9mm_P1.27mm
U4: LM5109MA; SOIC-8_3.9x4.9mm_P1.27mm
U5: INA240A1PW; TSSOP-8_4.4x3mm_P0.65mm
U7: SOT-23-5
U8: LM2675M-5; SOIC-8_3.9x4.9mm_P1.27mm
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C21.2, C25.2, C28.2, C29.2, C33.2, C34.2, C35.2, C43.2, J1.1, R9.2, R15.2, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.8 (V+), U5.5 (V+), U5.7 (REF1), U6.8 (V+), U7.5 (VOUT)
+5V: C31.1, C32.1, C36.1, L3.2, U7.1 (VIN), U7.3 (EN), U8.4 (FB)
+12V: C4.2, C6.1, C10.1, C37.1, D2.2 (A), L1.2, R3.2, U4.1 (VDD), U8.7 (VIN)
+24V: C12.1, C13.1, C15.1, C18.1, C19.1, C26.1, C27.1, C40.1, J5.2, R11.2, R13.2, R16.1
+48V: C1.1, C7.2, C8.2, C38.2, D1.1 (A1), D6.1 (A1), J2.2, Q1.5 (D), R19.1, U2.2 (VIN), U2.3 (EN/UVLO)
/BOOT0: R10.2, U1.60 (BOOT0)
/HRTIM_+: R8.2, U1.41 (PA8), U4.2 (HI)
/HRTIM_-: R7.2, U1.42 (PA9), U4.3 (LI)
/NRST: C11.2, R9.1, SW1.2, U1.7 (NRST)
/OSC_IN: C14.2, U1.5 (PF0), Y1.1
/OSC_OUT: C16.2, U1.6 (PF1), Y1.3
/SWCLK: J1.3, U1.49 (PA14)
/SWDIO: J1.2, U1.46 (PA13)
/USART3_RX: J1.6, U1.52 (PC11)
/USART3_TX: J1.5, U1.51 (PC10)
/adc_Vin: U1.35 (PB14), U3.1, U3.2 (-)
/adc_cir: R14.1, U1.34 (PB13)
/adc_volt: R18.2, U1.33 (PB12)
/comp_cirurt: R14.2, U1.26 (PB0), U5.8
/comp_volt: R18.1, U1.30 (PB11), U6.1, U6.2 (-)
GND: C1.2, C6.2, C7.1, C8.1, C10.2, C11.1, C12.2, C13.2, C14.1, C15.2, C16.1, C18.2, C19.2, C21.1, C25.1, C26.2, C27.2, C28.1, C29.1, C31.2, C32.2, C33.1, C34.1, C35.1, C36.2, C37.2, C38.1, C40.2, C43.1, D1.2 (A2), D5.1 (K), D6.2 (A2), D13.2 (A), J1.4, J1.MP (MountPin), J2.1, J5.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), R1.2, R4.1, R7.1, R8.1, R10.1, R17.2, R20.2, SW1.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.1 (GND), U2.9 (EP), U3.4 (V-), U4.4 (VSS), U5.1 (GND), U5.4 (GND), U5.6 (REF2), U6.4 (V-), U7.2 (GND), U7.4 (NC), U8.6 (GND), Y1.2, Y1.4
unnamed: C4.1, C5.2, R2.2
unnamed: C9.1, D2.1 (K), U4.8 (HB)
unnamed: D3.2 (A), Q1.4 (G), R5.2
unnamed: D3.1 (K), R5.1, U4.7 (HO)
unnamed: D4.2 (A), Q2.4 (G), R6.2
unnamed: D4.1 (K), R6.1, U4.5 (LO)
unnamed: D5.2 (A), R15.1
unnamed: C30.2, D13.1 (K), L3.1, U8.8 (VSW)
unnamed: L2.2, R11.1, R12.2
unnamed: C9.2, L2.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), U4.6 (HS)
unnamed: C3.1, U2.7 (BST)
unnamed: C5.1, R3.1, R4.2, U2.5 (FB)
unnamed: R1.1, U2.4 (RON)
unnamed: C3.2, L1.1, R2.1, U2.8 (SW)
unnamed: R19.2, R20.1, U3.3 (+)
unnamed: C22.2, R12.1, U5.2 (+)
unnamed: C22.1, R13.1, U5.3 (-)
unnamed: R16.2, R17.1, U6.3 (+)
unnamed: C30.1, U8.1 (CB)

Notes on the sheet:
12v to 5v dcdc电路

Board: 2 copper layers, 56.4 x 40.5 mm, 80 parts (33 on the bottom side), 40 nets.

## Code that names these connections

File program/CNC_buck/CNC_buck.ioc (part):

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Mcu.Name=STM32F334R(6-8)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F334R8Tx
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA8.Mode=Output_TA1TA2
PA8.Signal=HRTIM1_CHA1
PA9.Mode=Output_TA1TA2
PA9.Signal=HRTIM1_CHA2
PB0.Mode=INP
PB0.Signal=COMP4_INP
PB11.Mode=INP
PB11.Signal=COMP6_INP
PB12.Mode=IN13-Single-Ended
PB12.Signal=ADC2_IN13
PB13.Mode=IN13-Single-Ended
PB13.Signal=ADC1_IN13
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PC10.Mode=Asynchronous
PC10.Signal=USART3_TX
PC11.Mode=Asynchronous
PC11.Signal=USART3_RX
PF0\ /\ OSC_IN.Mode=HSE-External-Oscillator
PF0\ /\ OSC_IN.Signal=RCC_OSC_IN
PF1\ /\ OSC_OUT.Mode=HSE-External-Oscillator
PF1\ /\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-04-16 circuit_init
2026-04-28 commit sch
2026-04-30 finish circuir_V1.0
2026-05-04 配置了dac和comp和hrtim定时器
2026-05-04 buck电路板第一版
2026-05-05 添加了分层
2026-05-05 重命名hrtim.c为DAC.c并添加DAC相关头文件和实现
2026-05-05 添加STM32F3系列微控制器的基础代码和配置文件
2026-05-05 重构DAC相关代码，重命名头文件并添加新实现，更新CMake配置
2026-05-12 添加UART协议相关代码，更新ADC和DAC配置，修改GPIO和HRTIM设置
2026-05-12 PCB图自动保存
2026-05-16 recover second board layout
2026-05-16 recover version2.0
2026-05-16 完成第二版电路版布局
2026-05-17 重新对第二版pcb进行布局
2026-05-17 完成连线，还有几个报错
2026-05-19 完成pcb
2026-05-20 添加过压和过流保护功能，更新相关代码和头文件
2026-05-21 修改单片机的外设配置
